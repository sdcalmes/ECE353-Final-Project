# Keil uVision project ece353_base_project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.0.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ELITTLE
  output: ece353_base_project
  c flags: Optim=1
  c include: C:\Keil_v5\ARM\Pack\ARM\CMSIS\3.20.4\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c fonts.c adc.c gpioPort.c interrupts.c pc_buffer.c spi.c uart.c watchdog.c wireless.c boardUtil.c graphics.c eeprom.c i2c.c io_expander.c game.c button_debounce.c timers.c
  group lib
    ../lib/: ece353_project.lib
  group includes
    ../include/: adc.h eadogs102w.h fonts.h gptimer.h i2c.h ledMatrixChars.h mcp24LC32AT.h nordic.h spi.h sysctrl.h systick.h uart.h circular_buffer.h
  group headers
    ./: wireless.h spi.h watchdog.h pc_buffer.h gpioPort.h interrupts.h boardUtil.h gpio.h eeprom.h io_expander.h i2c.h graphics.h button_debounce.h timers.h game.h
  group ::Device
    RTE/Device/TM4C123GH6PM/: startup_TM4C123.s system_TM4C123.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
